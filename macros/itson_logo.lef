VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

UNITS
  DATABASE MICRONS 1000 ;
END UNITS

MACRO itson_logo
  CLASS BLOCK ;
  FOREIGN itson_logo 0 0 ;
  ORIGIN 0 0 ;
  SIZE 104.000 BY 44.000 ;
  SYMMETRY X Y ;
  OBS
    LAYER Metal2 ;
      RECT 2.000 2.000 102.000 42.000 ;
    LAYER Metal3 ;
      RECT 2.000 2.000 102.000 42.000 ;
  END
END itson_logo

END LIBRARY
